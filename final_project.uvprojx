# Keil uVision project final_project.uvprojx, settings and files
target STM32F407 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: final_project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\header;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./src/: BEEP.c board_ctrl.c display.c LCD.c LED.c menu.c multimeter.c SWT.c sys.c usart.c
    ./header/: BEEP.h board_ctrl.h LCD.h LED.h menu.h multimeter.h SWT.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 2.6.0
